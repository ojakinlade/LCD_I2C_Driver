# Keil uVision project LCD_I2C.uvprojx, settings and files
target stm32f407 (6160000::V6.16::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LCD_I2C
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main Application
    ./: main.c
  group High Level API
    ./: lcd.c lcd.h system.h system.c
  group Low Level API
    ./: clocks.c clocks.h gpio.c gpio.h i2c.c i2c.h systick.c systick.h
software components: CMSIS:CORE 5.4.0, Device:Startup 2.6.3
